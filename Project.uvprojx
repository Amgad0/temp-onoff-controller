# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\ti\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: tm4c123gh6pm.h LCD.c TempController.c main.c gpio_init.c uart.c adc.c app_tasks.c
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/: gpio.c
  group New Group
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.6.0, RTOS:Config 10.4.6, RTOS:Core 10.4.6, RTOS:Heap 10.4.6, Device:Startup 1.0.1
